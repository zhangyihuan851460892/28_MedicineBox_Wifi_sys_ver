# Keil uVision project SmartMedicineBox.uvproj, settings and files
target SMB (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: SmartMedicineBox +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\User;..\..\User\rtc;..\..\User\usart;..\..\User\led;..\..\User\SC5080;..\..\User\adc;..\..\User\AT24C256;..\..\User\TimBase;..\..\User\HT1621B;..\..\User\CJSON;..\..\User\ISD1700;..\..\User\ESP8266;..\..\User\Program;..\..\User\24CXX;..\..\User\IIC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP
    ../../User/led/: bsp_led.c
    ../../User/SC5080/: bsp_sc5080.c
    ../../User/adc/: bsp_adc.c
    ../../User/AT24C256/: bsp_i2c_ee.c
    ../../User/usart/: bsp_usart.c DeviceInit.c
    ../../User/TimBase/: bsp_TiMbase.c
    ../../User/CJSON/: cJSON.c
    ../../User/ISD1700/: bsp_isd1700.c
    ../../User/ESP8266/: bsp_esp8266.c AT_Protocol.c
    ../../User/HT1621B/: bsp_HT1624B.c
    ../../User/rtc/: bsp_calendar.c bsp_date.c bsp_rtc.c
    ../../User/24CXX/: 24cxx.c
    ../../User/IIC/: myiic.c
  group USER
    ../../User/: stm32f10x_conf.h stm32f10x_it.c MedicineBoxOperation.c Task.c main.c
  group RTX_OS
    ../../Libraries/CMSIS/: cmsis_os.h RTX_CM_lib.h RTX_CM3.lib RTX_Conf_CM.c
  group PROGRAM
    ../../User/Program/: common.c download.c ymodem.c
